# Keil uVision project gd32f450_freertos.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f450_freertos
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group software454
    ./454software/: 454software.c 454software.h sdcard.c sdcard.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS:FreeRTOS 10.5.1, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 3.0.2, Device:StdPeripherals:ADC 3.0.2, Device:StdPeripherals:CAN 3.0.2, Device:StdPeripherals:CRC 3.0.2, Device:StdPeripherals:CTC 3.0.2, Device:StdPeripherals:DAC 3.0.2, Device:StdPeripherals:DBG 3.0.2, Device:StdPeripherals:DCI 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:ENET 3.0.2, Device:StdPeripherals:EXMC 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:FMC 3.0.2, Device:StdPeripherals:FWDGT 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:I2C 3.0.2, Device:StdPeripherals:IPA 3.0.2, Device:StdPeripherals:IREF 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:RTC 3.0.2, Device:StdPeripherals:SDIO 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:TLI 3.0.2, Device:StdPeripherals:TRNG 3.0.2, Device:StdPeripherals:USART 3.0.2, Device:StdPeripherals:WWDGT 3.0.2
